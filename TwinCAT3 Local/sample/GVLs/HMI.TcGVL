{attribute 'qualified_only'}
VAR_GLOBAL
	Bool_Test :BOOL;
END_VAR
